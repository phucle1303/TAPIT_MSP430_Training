<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LDR\ldr.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\readpot\readpot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lm35\temperature.ewp</path>
  </project>
  <batchBuild/>
</workspace>


